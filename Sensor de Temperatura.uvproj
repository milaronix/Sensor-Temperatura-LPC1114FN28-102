# Keil uVision project Sensor de Temperatura.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: LPC1114/102 NXP
  cpu: IRAM(0x10000000-0x10000FFF) IROM(0-0x7FFF) CLOCK(12000000) CPUTYPE("Cortex-M0")
  output: Sensor de Temperatura +hex
  c flags: Optim=1
  memory RVCT4: ROM 0x0 size 0x8000
  memory RVCT9: RAM 0x10000000 size 0x1000
  group Source Group 1
    ./: startup_LPC11xx.s main.c system_LPC11xx.c
